# Repository brainsmoke/usb2_hub

File README.md:

# A USB 2 Hub with per-port-power and MTT

Production files (JLCPCB): [gerbers](build/hub/gerbers_jlc.zip) [BOM](build/hub/bomfile_jlc.csv) [POS](build/hub/posfile_jlc.csv)

This repository contains the [KiCad](https://www.kicad.org/) and [OpenScad](https://openscad.org/) files for a USB 2 Hub with per-port power and MTT.

The PCB design contains 4 USB-A ports and 1 USB-C port. The latter is used to connect the device to a computer.

If you want to switch power to ports you can use the provided [kernel interface](https://www.kernel.org/doc/html/latest/driver-api/usb/power-management.html#user-interface-for-port-power-control) or a userland utility such as [uhubctl](https://github.com/mvp/uhubctl).

## Case

OpenSCAD and STL files are available. These can be used to 3D print a case for the hub. The case can be assembled using countersunk M3 bolts with a maximum length of 8 mm.

* [Bottom](./build/hub/case_bottom.stl)
* [Top](./build/hub/case_top.stl)

## Revision errata:

### v0.7

* No known errata

### v0.4

* A capacitor and a USB-A connector are in the same place.

### v0.1

* instead of a 100k (busb <-> gnd) on r11, solder two 100k resistors from each of r11's pads
  to each of r10's pads (busb <-> 5v & gnd <-> vbusm)

## KiCad design pcb/project.kicad_pcb

Parts:
C1, C2: 12pF; C_0603_1608Metric; LCSC C38523
C3, C4, C21, C22, C23, C24, C27, C28, C29, C31: 100nF; C_0603_1608Metric; LCSC C14663
C25, C26, C30: 10uF; C_0805_2012Metric; LCSC C15850
D9: LED; LED_0805_2012Metric; LCSC C2297
D14: LED; LED_0805_2012Metric; LCSC C965819
J5: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J6: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical; not fitted
R5, R6: 5k1; R_0603_1608Metric; LCSC C23186
R7, R28: 12k; R_0603_1608Metric; LCSC C22790
R8: 2K7 (1%); R_0603_1608Metric; LCSC C13167
R9, R10, R29: 100k; R_0603_1608Metric; LCSC C25803
R11: 47k; R_0603_1608Metric; LCSC C25819
U1: FE1.1; LQFP-48_7x7mm_P0.5mm; LCSC C28958
U6: USBLC6-2SC6; SOT-23-6; LCSC C7519
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C50430

Connections:
1V8: C26.1, C27.1, C28.1, C29.1, U1.3 (VD18), U1.9 (VD_PLL), U1.26 (VREG18), U1.29 (VD18)
3V3: C21.1, C22.1, C23.1, C24.1, C25.1, R9.2, U1.13 (VD33), U1.19 (VD33), U1.27 (VD33_IN), U1.32 (VD33), U1.39 (VD33_OUT), U1.41 (VD33)
5V: C30.1, C31.1, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), J6.2, R10.2, R11.2, R28.1, U1.38 (VD5_IN), U6.5 (VBUS); also elsewhere on the board
/d+: U1.31 (DPU), U6.1 (I/O1)
/d-: U1.30 (DMU), U6.3 (I/O2)
D1+: U1.24 (DP1); also elsewhere on the board
D1-: U1.23 (DM1); also elsewhere on the board
D2+: U1.21 (DP2); also elsewhere on the board
D2-: U1.20 (DM2); also elsewhere on the board
D3+: U1.18 (DP3); also elsewhere on the board
D3-: U1.17 (DM3); also elsewhere on the board
D4+: U1.15 (DP4); also elsewhere on the board
D4-: U1.14 (DM4); also elsewhere on the board
DRV: R7.1, U1.42 (DRV); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, D9.1 (K), D14.1 (K), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), J6.1, R5.2, R6.2, R8.2, R29.1, U1.6 (VSS), U1.10 (VS_PLL), U1.16 (VSS), U1.22 (VSS), U1.25 (VS_A), U1.33 (VSS), U1.37 (DIS_REG), U1.40 (TEST), U6.2 (GND), Y1.2, Y1.4; also elsewhere on the board
LED1: U1.43 (LED1); also elsewhere on the board
LED2: U1.44 (LED2); also elsewhere on the board
LED3: U1.45 (LED3); also elsewhere on the board
LED4: U1.46 (LED4); also elsewhere on the board
unnamed: D9.2 (A), R7.2
unnamed: D14.2 (A), R28.2
unnamed: J5.A5 (CC1), R5.1
unnamed: J5.B5 (CC2), R6.1
unnamed: J5.A6 (D+), J5.B6 (D+), U6.6 (I/O1)
unnamed: J5.A7 (D-), J5.B7 (D-), U6.4 (I/O2)
unnamed: R10.1, U1.36 (BUSB)
unnamed: R8.1, U1.28 (REXT)
unnamed: C4.1, R11.1, R29.2, U1.35 (VBUSM)
unnamed: C3.1, R9.1, U1.34 (~XRSTJ)
OVERCURRENT1: U1.48 (OVCB1); also elsewhere on the board
OVERCURRENT2: U1.1 (OVCB2); also elsewhere on the board
OVERCURRENT3: U1.5 (OVCB3); also elsewhere on the board
OVERCURRENT4: U1.7 (OVCB4); also elsewhere on the board
USB_EN1: U1.47 (PWRB1); also elsewhere on the board
USB_EN2: U1.2 (PWRB2); also elsewhere on the board
USB_EN3: U1.4 (PWRB3); also elsewhere on the board
USB_EN4: U1.8 (PWRB4); also elsewhere on the board
XIN: C2.1, U1.12 (XIN), Y1.3
XOUT: C1.1, U1.11 (XOUT), Y1.1

Parts:
C8: 10uF; C_0805_2012Metric; LCSC C15850
C12, C20: 100nF; C_0603_1608Metric; LCSC C14663
C16: 22uF; C_1206_3216Metric; LCSC C12891
D7: LED; LED_0805_2012Metric; LCSC C965812
D8: LED; LED_0805_2012Metric; LCSC C2297
D13: LED; LED_0805_2012Metric; LCSC C965819
J4: USB_A; SHOU HAN 10.0 QHHTZB6.3; LCSC C668591
R20: 100k; R_0603_1608Metric; LCSC C25803
R21, R22, R23, R27: 12k; R_0603_1608Metric; LCSC C22790
U5: AP22652AW6-7; SOT-23-6; LCSC C5329413
U10: USBLC6-2SC6; SOT-23-6; LCSC C7519

Connections:
5V: C8.1, C12.1, R22.2, U5.1 (VIN); also elsewhere on the board
D4+: U10.4 (I/O2); also elsewhere on the board
D4-: U10.6 (I/O1); also elsewhere on the board
DRV: D7.1 (K), D8.2 (A); also elsewhere on the board
GND: C8.2, C12.2, C16.2, C20.2, D13.1 (K), J4.4 (GND), J4.5 (Shield), R20.1, R21.1, U5.2 (GND), U10.2 (GND); also elsewhere on the board
LED4: R23.1; also elsewhere on the board
unnamed: D7.2 (A), D8.1 (K), R23.2
unnamed: D13.2 (A), R27.2
unnamed: J4.3 (D+), U10.3 (I/O2)
unnamed: J4.2 (D-), U10.1 (I/O1)
unnamed: R21.2, U5.5 (ILIM)
OVERCURRENT4: R22.1, U5.4 (~FAULT); also elsewhere on the board
USB_EN4: R20.2, U5.3 (~EN); also elsewhere on the board
VUSB4: C16.1, C20.1, J4.1 (VBUS), R27.1, U5.6 (VOUT), U10.5 (VBUS)

Parts of its further copies:
C5, C6, C7: 10uF; C_0805_2012Metric; LCSC C15850
C9, C10, C11, C17, C18, C19: 100nF; C_0603_1608Metric; LCSC C14663
C13, C14, C15: 22uF; C_1206_3216Metric; LCSC C12891
D1, D3, D5: LED; LED_0805_2012Metric; LCSC C965812
D2, D4, D6: LED; LED_0805_2012Metric; LCSC C2297
D10, D11, D12: LED; LED_0805_2012Metric; LCSC C965819
J1, J2, J3: USB_A; SHOU HAN 10.0 QHHTZB6.3; LCSC C668591
R1, R3, R4, R13, R14, R15, R17, R18, R19, R24, R25, R26: 12k; R_0603_1608Metric; LCSC C22790
R2, R12, R16: 100k; R_0603_1608Metric; LCSC C25803
U2, U3, U4: AP22652AW6-7; SOT-23-6; LCSC C5329413
U7, U8, U9: USBLC6-2SC6; SOT-23-6; LCSC C7519

Connections of its further copies:
5V: C5.1, C6.1, C7.1, C9.1, C10.1, C11.1, R4.2, R14.2, R18.2, U2.1 (VIN), U3.1 (VIN), U4.1 (VIN); also elsewhere on the board
D1+: U7.4 (I/O2); also elsewhere on the board
D1-: U7.6 (I/O1); also elsewhere on the board
D2+: U8.4 (I/O2); also elsewhere on the board
D2-: U8.6 (I/O1); also elsewhere on the board
D3+: U9.4 (I/O2); also elsewhere on the board
D3-: U9.6 (I/O1); also elsewhere on the board
DRV: D1.1 (K), D2.2 (A), D3.1 (K), D4.2 (A), D5.1 (K), D6.2 (A); also elsewhere on the board
GND: C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, D10.1 (K), D11.1 (K), D12.1 (K), J1.4 (GND), J1.5 (Shield), J2.4 (GND), J2.5 (Shield), J3.4 (GND), J3.5 (Shield), R2.1, R3.1, R12.1, R13.1, R16.1, R17.1, U2.2 (GND), U3.2 (GND), U4.2 (GND), U7.2 (GND), U8.2 (GND), U9.2 (GND); also elsewhere on the board
LED1: R1.1; also elsewhere on the board
LED2: R15.1; also elsewhere on the board
LED3: R19.1; also elsewhere on the board
unnamed: D1.2 (A), D2.1 (K), R1.2
unnamed: D3.2 (A), D4.1 (K), R15.2
unnamed: D5.2 (A), D6.1 (K), R19.2
unnamed: D10.2 (A), R24.2
unnamed: D11.2 (A), R25.2
unnamed: D12.2 (A), R26.2
unnamed: J1.3 (D+), U7.3 (I/O2)
unnamed: J1.2 (D-), U7.1 (I/O1)
unnamed: J2.3 (D+), U8.3 (I/O2)
unnamed: J2.2 (D-), U8.1 (I/O1)
unnamed: J3.3 (D+), U9.3 (I/O2)
unnamed: J3.2 (D-), U9.1 (I/O1)
unnamed: R13.2, U2.5 (ILIM)
unnamed: R3.2, U3.5 (ILIM)
unnamed: R17.2, U4.5 (ILIM)
OVERCURRENT1: R14.1, U2.4 (~FAULT); also elsewhere on the board
OVERCURRENT2: R4.1, U3.4 (~FAULT); also elsewhere on the board
OVERCURRENT3: R18.1, U4.4 (~FAULT); also elsewhere on the board
USB_EN1: R12.2, U2.3 (~EN); also elsewhere on the board
USB_EN2: R2.2, U3.3 (~EN); also elsewhere on the board
USB_EN3: R16.2, U4.3 (~EN); also elsewhere on the board
VUSB1: C13.1, C17.1, J1.1 (VBUS), R24.1, U2.6 (VOUT), U7.5 (VBUS)
VUSB2: C14.1, C18.1, J2.1 (VBUS), R25.1, U3.6 (VOUT), U8.5 (VBUS)
VUSB3: C15.1, C19.1, J3.1 (VBUS), R26.1, U4.6 (VOUT), U9.5 (VBUS)

Board: 4 copper layers, 46.0 x 86.0 mm, 91 parts (0 on the bottom side), 63 nets.

File pcb/bom.csv:

"Comment","Designator","Footprint","JLCPCB Part #"
"12pF","C1,C2","Capacitor_SMD:C_0603_1608Metric","C38523"
"100nF","C3,C4,C9,C10,C11,C12,C17,C18,C19,C20,C21,C22,C23,C24,C27,C28,C29,C31","Capacitor_SMD:C_0603_1608Metric","C14663"
"10uF","C5,C6,C7,C8,C25,C26,C30","Capacitor_SMD:C_0805_2012Metric","C15850"
"22uF","C13,C14,C15,C16","Capacitor_SMD:C_1206_3216Metric","C12891"
"LED","D1,D3,D5,D7","LED_SMD:LED_0805_2012Metric","C965812"
"LED","D2,D4,D6,D8,D9","LED_SMD:LED_0805_2012Metric","C2297"
"LED","D10,D11,D12,D13,D14","LED_SMD:LED_0805_2012Metric","C965819"
"USB_A","J1,J2,J3,J4","Library:SHOU HAN 10.0 QHHTZB6.3","C668591"
"USB_C_Receptacle_USB2.0_16P","J5","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12","C165948"
"12k","R1,R3,R4,R7,R13,R14,R15,R17,R18,R19,R21,R22,R23,R24,R25,R26,R27,R28","Resistor_SMD:R_0603_1608Metric","C22790"
"100k","R2,R9,R10,R12,R16,R20,R29","Resistor_SMD:R_0603_1608Metric","C25803"
"5k1","R5,R6","Resistor_SMD:R_0603_1608Metric","C23186"
"2K7 (1%)","R8","Resistor_SMD:R_0603_1608Metric","C13167"
"47k","R11","Resistor_SMD:R_0603_1608Metric","C25819"
"FE1.1","U1","Package_QFP:LQFP-48_7x7mm_P0.5mm","C28958"
"AP22652AW6-7","U2,U3,U4,U5","Package_TO_SOT_SMD:SOT-23-6","C5329413"
"USBLC6-2SC6","U6,U7,U8,U9,U10","Package_TO_SOT_SMD:SOT-23-6","C7519"
"12MHz","Y1","Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm","C50430"

## Commit log

2024-08-07 usb hub, untested
2024-08-07 add readme
2024-08-09 hopefully improve layout, still untested
2024-08-19 add image
2024-08-20 v0.3
2024-08-21 use pull-up instead of pull-down on bus power input
2024-08-21 fix missing resistor
2024-08-21 add bodges to readme
2024-08-22 add pcba files
2024-08-22 add license
2024-08-22 add OSHW logo
2024-08-28 fix component overlap
2024-09-03 fix part number
2024-09-03 fix clearance issue
2024-09-04 add lasercut/3dprinted case & unfinished 3d print only design
2024-09-07 minor clearance tweaks
2024-09-07 update USB A footprint to use the same center location as JLCPCB uses
2024-09-08 layout: move case into cad subdirectory
    Just to make the layout similar to the one suggested in
    [this](https://github.com/brainsmoke/usb_proto/pull/3) PR.
2024-09-08 doc: expand README
    Mentions kernel an userland interface, adds a blurb about what this
    repository contains.
2024-09-08 add jlc posfile converter
2024-09-09 add case, untested
2024-09-09 add missing light pipe holes
2024-09-09 fix port orientations (oops)
2024-09-09 fix led positions
2024-09-09 doc: mention case and bolts
2024-09-09 doc: image of case
    Add an image of the case and hub.
2024-09-09 doc: fix typo
2024-09-10 raise connctors in model, hopefully improve light pipe
2024-09-15 add cases without light pipes / for the first iteration of the PCB / tweak model to reduce stringing
2024-09-16 use makefile to generate kicad fabrication outputs
2024-09-16 use a single Makefile
2024-09-16 cleanup
2024-09-16 move misplaced files
2024-09-16 remove old bomfile
2024-09-17 add lightpipe model
2024-09-18 Check in PCB 3d model
2024-09-18 Add alternate lightpipe for 3-led groups
2024-09-26 Add 2 led lightpipe
2024-11-06 use separate resistor for red LED
2024-11-07 use new makefile
2024-11-09 add order number location
2024-12-01 typo
2025-01-13 strengthen case, use filament as light pipes
2025-01-13 fix drc warnings
2025-01-13 add case.scad dependency to Makefile
2025-01-14 improve led pipes, fix extrusion interfering with case walls
2025-01-15 ignore frequent library footprint mismatches due to software updates
2025-01-20 retstore DRC warning as kicad no longer fails on mismatching comment fiels in 8.0.8
2025-01-20 fix silkscreen overlap
2025-01-20 remove references again
2025-03-01 recalculate usb trace impedance
2025-05-04 Ignore lib footprint mismatches because they keep changing
2025-05-27 revert to old impedance matching, (matching) JLC economy stackup
2025-05-27 gerbers
2025-06-06 link top to top instead of bottom
2025-09-14 update makefile
2026-04-29 update Makfile
2026-05-21 [README] add link to production files

Notices in the files:
pcb/project.kicad_pcb:
CC-BY-4.0
